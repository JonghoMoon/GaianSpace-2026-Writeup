options:
  parameters:
    author: Tapparel Joachim@EPFL,TCL
    generate_options: no_gui
    id: lora_RX
    output_language: python
  states: {}

blocks:
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/jhmoon/lora_decode.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jhmoon/gaianspace/Day 2/131_A_replies/131_A_reply_1.cf32
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: '500000'
    sf: '9'
    soft_decoding: 'False'
    sync_word: '[0x12]'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: ccc
  states: {}

connections:
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [lora_rx_0, '0', blocks_file_sink_0, '0']
- [lora_rx_0, out, blocks_message_debug_0, print]
- [rational_resampler_xxx_0, '0', lora_rx_0, '0']

metadata:
  file_format: 1
